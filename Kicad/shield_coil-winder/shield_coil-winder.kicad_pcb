# Repository jonathan-iap/CoilWinder

File README.md:

# CoilWinder

## Version : 1

### Abstract :

An evolutive coil winder machine based on *Arduino*.
The format of this machine can easily be adapted and upgraded for any coils.

---

### State of development :

  * Hardware -> functional
  * Software -> v1.0 : ok for coils production. Homing not working properly.

Software is write with the help of *platformIO* and *Eclipse*.
If you want to compile with *Arduino IDE* you need to create _*.ino_ file and add librairies in your path.

## KiCad design Kicad/shield_coil-winder/shield_coil-winder.kicad_pcb

Parts:
C1, C2, C3: 100uF; C_Horiz_15.5x6.5
C4: 100nF; C_Disc_D3_P2.5
D1, D4: LED; LED-3MM
D2, D3: 1N4004; Diode_DO-41_SOD81_Horizontal_RM10
DS1: LCD16X2; WC1602A
F1: MF-R050; RV_Disc_D7_W3.4_P5
K1: SOCKET_DRIVER_A; Driver_Socket
K2: SOCKET_DRIVER_B; Driver_Socket
P1: Power; Socket_Strip_Arduino_1x08
P2: Analog; Socket_Strip_Arduino_1x06
P3: Digital; Socket_Strip_Arduino_1x10
P4: Digital; Socket_Strip_Arduino_1x08
P5, P6, P7, P8: CONN_01X01; Arduino_1pin
P9, P10: MicroSteps; Pin_Header_Straight_2x03
P11: MOTOR-A; Pin_Header_Straight_1x04
P12: MOTOR-B; Pin_Header_Straight_1x04
P13: ALIM_EXT; bornier2
R1, R3, R6: 10K; Resistor_Horizontal_RM10mm
R2, R4: 100K; Resistor_Horizontal_RM10mm
R5: 1K; Resistor_Horizontal_RM10mm
SW1: ROTARY_ENCODER_SWITCH; Rotary_encoder-ALPS
SW2: SW_PUSH; SW_PUSH_6mm
U1: i2C_LCD-PCF8574; PCF8574_Board

Connections:
+5V: K1.15 (VDD), K2.15 (VDD), P1.5, P9.1, P9.3, P9.5, P10.1, P10.3, P10.5, R1.1, R3.1, U1.19 (VCC)
/0(Rx): P4.8
/1(Tx): P4.7
/11(**/MOSI): P3.7
/12(MISO): P3.6
/A0: P2.1
/A1: P2.2
/A2: P2.3
/A3: P2.4
/A4: P2.5
/A4(SDA): P3.2, U1.18 (SDA)
/A5: P2.6
/A5(SCL): P3.1, U1.17 (SCL)
/AREF: P3.3
/DIR-A_10: K1.8 (DIR), P3.8
/DIR-B_7: K2.8 (DIR), P4.1
/EN-A_8: K1.1 (EN), P3.10, R1.2
/EN-B_5: K2.1 (EN), P4.3, R3.2
/IOREF: P1.2
/IT_2: P4.6, SW1.1 (A)
/IT_3: P4.5, SW1.3 (B)
/LED_13(SCK): D1.2 (A), P3.5
/STEP-A_9: K1.7 (STEP), P3.9
/STEP-B_6: K2.7 (STEP), P4.2
/SW-ENC_4: P4.4, SW1.4
GND: C1.2, C2.2, C3.2, C4.2, D2.2 (A), DS1.0, K1.10 (GND), K1.16 (GND), K2.10 (GND), K2.16 (GND), P1.6, P1.7, P3.4, P5.1, P6.1, P7.1, P8.1, P13.2, R2.2, R4.2, R5.1, R6.1, SW1.2 (C), SW1.5, SW2.2, U1.20 (GND)
unnamed: D1.1 (K), R5.2
unnamed: D4.1 (K), R6.2
unnamed: DS1.1 (VSS), U1.1 (VSS)
unnamed: DS1.2 (VDD), U1.2 (VDD)
unnamed: DS1.3 (VO), U1.3 (V0)
unnamed: DS1.4 (RS), U1.4 (RS)
unnamed: DS1.5 (R/W), U1.5 (RW)
unnamed: DS1.6 (E), U1.6 (E)
unnamed: DS1.7 (D0), U1.7 (D0)
unnamed: DS1.8 (D1), U1.8 (D1)
unnamed: DS1.9 (D2), U1.9 (D2)
unnamed: DS1.10 (D3), U1.10 (D3)
unnamed: DS1.11 (D4), U1.11 (D4)
unnamed: DS1.12 (D5), U1.12 (D5)
unnamed: DS1.13 (D6), U1.13 (D6)
unnamed: DS1.14 (D7), U1.14 (D7)
unnamed: DS1.15 (LED+), U1.15 (A)
unnamed: DS1.16 (LED-), U1.16 (K)
unnamed: F1.1, P13.1
unnamed: K1.2 (MS1), P9.2, R2.1
unnamed: K1.3 (MS2), P9.4
unnamed: K1.4 (MS3), P9.6
unnamed: K1.5 (RST), K1.6 (SLEEP)
unnamed: K1.11 (B2), P11.1
unnamed: K1.12 (B1), P11.2
unnamed: K1.13 (A1), P11.3
unnamed: K1.14 (B1), P11.4
unnamed: K2.2 (MS1), P10.2, R4.1
unnamed: K2.3 (MS2), P10.4
unnamed: K2.4 (MS3), P10.6
unnamed: K2.5 (RST), K2.6 (SLEEP)
unnamed: K2.11 (B2), P12.1
unnamed: K2.12 (B1), P12.2
unnamed: K2.13 (A1), P12.3
unnamed: K2.14 (B1), P12.4
RESET: P1.3, SW2.1
VCC: C1.1, C2.1, C3.1, C4.1, D2.1 (K), D3.2 (A), D4.2 (A), F1.2, K1.9 (VMOT), K2.9 (VMOT)
Vin: D3.1 (K), P1.8

Notes on the sheet:
Holes
Shield for Arduino that uses the same pin disposition like "Uno" board Rev 3.
Action commands
External power source
Steppers motors drivers
LCD display
POWER FLAG
Note : Compatible with A4988 and DRV8834
Note : In this case the PCF8574 is a complete module who is plugin on to the back side of the LCD display.

Board: 2 copper layers, 68.6 x 89.4 mm, 34 parts (0 on the bottom side), 52 nets.

## Commit log

2016-08-31 add freecad first freecad files and export stl*
2016-09-10 Adding pictures
2016-09-10 Remove blur pictures
2016-09-11 Adding kicad files
2016-09-14 Adding pulley
2016-09-24 synch
2016-09-24 testguide V0.2
2016-10-02 guide V0.3
2016-10-07 PCB v1.0
2016-10-08 Image of new guide and pcb V1.0
2016-10-09 V1.1 pcb
2016-10-14 First commit arduino V0.1
2016-10-15 Correction label pin on sockets
2016-10-23 adding .versions folder to rescue versions
2016-10-29 prepare to create branch
2016-10-29 v0.10-Nok
2016-11-01 V0.11-ok
2016-11-06 v0.12-ok add screen dependance
2016-11-12 v0.13-ok fix start deceleration and microstep stepping
2016-12-02 v0.14-ok begin menu navigation
2016-12-03 v0.15-ok first implementation of navigation menu
2016-12-04 v0.16-ok change name file for edit menu and philosophy
2016-12-05 v0.17-ok add lcd pointer in display.h and test menu setting
2016-12-05 add general function
2016-12-05 change menu setting object (lcd and encoder) and pass funcion in private
2016-12-08 Adding buffer compar function not tested
2016-12-10 Improve eeprom memory and minor correction on edit menu
2016-12-11 continu on eeprom memorie
2016-12-17 work on eeprom memory
2016-12-17 v0.17-ok read eeprom and set value
2016-12-17 dev_software : v0.18-ok read eeprom and set value
2016-12-18 v0.19-ok migrated all display actions
2016-12-20 save value updated in eeprom ok
2016-12-20 implement reset action
2016-12-21 add menuStructures and refresh files
2016-12-22 Hardware carriage v0.4 and software v0.20
2016-12-23 Work on movement
2016-12-23 Error on computing() must be reworked
2016-12-29 v0.21 memory reworked, delete memory object and work only with the class
2017-01-09 Add setting, max, min, acc and try to correct acceleration steps
2017-01-13 Fix calculation of steps deceleration youpi !
2017-01-14 re-convert all double into float
2017-01-14 Use display object in class Setting
2017-01-14 change message valid for next
2017-01-17 Separate computing function
2017-01-17 Implement displacement coil
2017-01-17 Rebuild displacement carriage
2017-01-18 Implement first stage for automatic winding
2017-01-18 Add homing() function, to resume start position.
2017-01-18 Pass object to class setting and coil
2017-01-19 First work on suspend menu
2017-01-19 implement back in suspend menu, exit work but need to be reworked
2017-01-29 Suspend mode and recovery current winding work
2017-01-29 Work on suspend mode
    Fix display value, and resume mode
2017-02-01 First implementation for setting current speed
2017-02-01 Update current speed work
2017-02-01 First implementation of save current winding
2017-02-02 Save current winding work
2017-02-02 First implementation of rework menu
2017-02-02 Display custom characters in array works
2017-02-04 cursor displacement not work
2017-02-06 Cursor displacement fix
2017-02-06 Change return variable of bufferCmp()
2017-02-06 Edit value work
2017-02-11 Fix navigation and selection icons
2017-02-11 Refactore menuSetting
2017-02-12 update and saving value work
2017-02-12 fix overflow
2017-02-14 Ajust menu reset and RAZ (work)
2017-02-14 Simple move add
2017-02-16 Continu rework menu and fix cursor mouvement
2017-02-16 add saved and resume function when winding
2017-02-16 cleane up project
2017-02-18 Remove example in libraries and adjust variable type
2017-02-25 fix steps count
2017-02-25 Add fastIio.h and change motor control
2017-02-26 prepare memory for save sense of winding
2017-02-26 Change the layout of the menu
2017-03-04 add homing position
2017-03-05 fix resume coil layer
2017-03-05 fix set home move
2017-03-12 Change i2c frequency and prepar for new branch
2017-03-19 Rework encoder
2017-08-08 update pio and change timer for encoder
2017-08-08 suppr clamp function and replace by constrain
2017-08-08 suppr motors code and start new dev on timerOne
2017-08-08 change define name for pins
2017-08-12 speed set by rpm
2017-08-13 carriage displacement is correct
2017-08-13 add a message fo max speed value
2017-08-13 add speed ajust with encoder
2017-08-15 function "move coil or carriage only" is working
2017-08-15 commit not work!
2017-08-15 fix display travel
2017-08-16 add acc increment setting and acceleration
2017-08-16 ignore winding function
2017-08-16 start to add sense of winding
2017-08-16 set sense and save in eeprom work
2017-08-16 change float to int16
2017-08-16 homing work
2017-08-17 simple winding work's but not at full well at full speed
2017-08-17 fix memory init
2017-08-17 fix display value when save
2017-08-17 prepare for save winding and correct display
2017-08-18 work on saving winding state
2017-08-18 read and write state winding seem to be worked
2017-08-21 fix update value
2017-08-23 fix sense when save or resume winding
2017-08-27 fix if wire is greter than lead screw pitch
2017-09-02 homing only carriage not after winding improve
2017-10-22 Smooth displacement
2017-12-07 add RAZ option when value is edited
2017-12-07 correct img readme
2017-12-29 hardware rework
2017-12-30 news supports and centering coil
2017-12-31 stl export
2018-01-21 Add pictures and somes *STL files
2018-01-21 correct img path
